# Keil uVision project DriverSTM.uvprojx, settings and files
target Reel (6150000::V6.15::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DriverSTM
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: Driver_GPIO.c
  group Include
    ./: Driver_GPIO.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
